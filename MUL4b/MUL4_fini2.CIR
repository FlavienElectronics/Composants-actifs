CIRCUIT C:\Users\Flavien\OneDrive - INSA Toulouse\4A_AE_SE\Composant actif\MUL4b\MUL4_fini2.MSK
*
* IC Technology: CMOS 3nm - 8 Metal copper - NSFET
*
VDD 1 0 DC 0.650
VA0 709 0 DC 0 PULSE(0.00 0.650 0.04N 0.005N 0.01N 0.045N 0.100N)
VB3 710 0 DC 0 PULSE(0.00 0.650 6.39N 0.005N 0.01N 6.395N 12.800N)
VB2 711 0 DC 0 PULSE(0.00 0.650 3.19N 0.005N 0.01N 3.195N 6.400N)
VB0 712 0 DC 0 PULSE(0.00 0.650 0.80N 0.005N 0.01N 0.795N 1.600N)
VA2 714 0 DC 0 PULSE(0.00 0.650 0.20N 0.005N 0.00N 0.195N 0.400N)
VB1 717 0 DC 0 PULSE(0.00 0.650 1.59N 0.005N 0.01N 1.595N 3.200N)
VA1 718 0 DC 0 PULSE(0.00 0.650 0.10N 0.005N 0.01N 0.095N 0.200N)
VA3 725 0 DC 0 PULSE(0.00 0.650 0.40N 0.005N 0.00N 0.395N 0.800N)
*
* List of nodes
* "P1" corresponds to n°2
* "P0" corresponds to n°3
* "P3" corresponds to n°5
* "N7" corresponds to n°7
* "P2" corresponds to n°8
* "N9" corresponds to n°9
* "AixBi" corresponds to n°72, WARNING: appears 16 times in the layout
* "AixBi" corresponds to n°76, WARNING: appears 16 times in the layout
* "AixBi" corresponds to n°86, WARNING: appears 16 times in the layout
* "AixBi" corresponds to n°90, WARNING: appears 16 times in the layout
* "N101" corresponds to n°101
* "N103" corresponds to n°103
* "N105" corresponds to n°105
* "P4" corresponds to n°110
* "A3" corresponds to n°111, WARNING: appears 4 times in the layout
* "N113" corresponds to n°113
* "N116" corresponds to n°116
* "N117" corresponds to n°117
* "N119" corresponds to n°119
* "N122" corresponds to n°122
* "N123" corresponds to n°123
* "N125" corresponds to n°125
* "N126" corresponds to n°126
* "N128" corresponds to n°128
* "N129" corresponds to n°129
* "N130" corresponds to n°130
* "N131" corresponds to n°131
* "N132" corresponds to n°132
* "N133" corresponds to n°133
* "N134" corresponds to n°134
* "N135" corresponds to n°135
* "N136" corresponds to n°136
* "N137" corresponds to n°137
* "N138" corresponds to n°138
* "N139" corresponds to n°139
* "N140" corresponds to n°140
* "N141" corresponds to n°141
* "N143" corresponds to n°143
* "N144" corresponds to n°144
* "N149" corresponds to n°149
* "N154" corresponds to n°154
* "N155" corresponds to n°155
* "N159" corresponds to n°159
* "N167" corresponds to n°167
* "N168" corresponds to n°168
* "N169" corresponds to n°169
* "N170" corresponds to n°170
* "N171" corresponds to n°171
* "N172" corresponds to n°172
* "N173" corresponds to n°173
* "N174" corresponds to n°174
* "N175" corresponds to n°175
* "AixBi" corresponds to n°179, WARNING: appears 16 times in the layout
* "N183" corresponds to n°183
* "AixBi" corresponds to n°184, WARNING: appears 16 times in the layout
* "N187" corresponds to n°187
* "AixBi" corresponds to n°188, WARNING: appears 16 times in the layout
* "N191" corresponds to n°191
* "N192" corresponds to n°192
* "N193" corresponds to n°193
* "N195" corresponds to n°195
* "N196" corresponds to n°196
* "AixBi" corresponds to n°197, WARNING: appears 16 times in the layout
* "N200" corresponds to n°200
* "N201" corresponds to n°201
* "N203" corresponds to n°203
* "N204" corresponds to n°204
* "N207" corresponds to n°207
* "N211" corresponds to n°211
* "P5" corresponds to n°214
* "A3" corresponds to n°215, WARNING: appears 4 times in the layout
* "N217" corresponds to n°217
* "N220" corresponds to n°220
* "N221" corresponds to n°221
* "N224" corresponds to n°224
* "N226" corresponds to n°226
* "N228" corresponds to n°228
* "N229" corresponds to n°229
* "N231" corresponds to n°231
* "N232" corresponds to n°232
* "N233" corresponds to n°233
* "N234" corresponds to n°234
* "N235" corresponds to n°235
* "N236" corresponds to n°236
* "N237" corresponds to n°237
* "N238" corresponds to n°238
* "N239" corresponds to n°239
* "N240" corresponds to n°240
* "N241" corresponds to n°241
* "N242" corresponds to n°242
* "N243" corresponds to n°243
* "N244" corresponds to n°244
* "N245" corresponds to n°245
* "N246" corresponds to n°246
* "N248" corresponds to n°248
* "N249" corresponds to n°249
* "N251" corresponds to n°251
* "N252" corresponds to n°252
* "N260" corresponds to n°260
* "N271" corresponds to n°271
* "N272" corresponds to n°272
* "N273" corresponds to n°273
* "N274" corresponds to n°274
* "N276" corresponds to n°276
* "N277" corresponds to n°277
* "N278" corresponds to n°278
* "N279" corresponds to n°279
* "N280" corresponds to n°280
* "N281" corresponds to n°281
* "N284" corresponds to n°284
* "AixBi" corresponds to n°285, WARNING: appears 16 times in the layout
* "N289" corresponds to n°289
* "AixBi" corresponds to n°290, WARNING: appears 16 times in the layout
* "B2" corresponds to n°293, WARNING: appears 2 times in the layout
* "AixBi" corresponds to n°294, WARNING: appears 16 times in the layout
* "N298" corresponds to n°298
* "AixBi" corresponds to n°299, WARNING: appears 16 times in the layout
* "N302" corresponds to n°302
* "N303" corresponds to n°303
* "N304" corresponds to n°304
* "N305" corresponds to n°305
* "N306" corresponds to n°306
* "N308" corresponds to n°308
* "N309" corresponds to n°309
* "N312" corresponds to n°312
* "P6" corresponds to n°318
* "A3" corresponds to n°319, WARNING: appears 4 times in the layout
* "B3" corresponds to n°321, WARNING: appears 3 times in the layout
* "P7" corresponds to n°325
* "B3" corresponds to n°326, WARNING: appears 3 times in the layout
* "N327" corresponds to n°327
* "N329" corresponds to n°329
* "N333" corresponds to n°333
* "N334" corresponds to n°334
* "N335" corresponds to n°335
* "N336" corresponds to n°336
* "N337" corresponds to n°337
* "N338" corresponds to n°338
* "N339" corresponds to n°339
* "N340" corresponds to n°340
* "N341" corresponds to n°341
* "N342" corresponds to n°342
* "N343" corresponds to n°343
* "N344" corresponds to n°344
* "N345" corresponds to n°345
* "N346" corresponds to n°346
* "N347" corresponds to n°347
* "N348" corresponds to n°348
* "N349" corresponds to n°349
* "N350" corresponds to n°350
* "N351" corresponds to n°351
* "N352" corresponds to n°352
* "N354" corresponds to n°354
* "N355" corresponds to n°355
* "N356" corresponds to n°356
* "N376" corresponds to n°376
* "N377" corresponds to n°377
* "N378" corresponds to n°378
* "N379" corresponds to n°379
* "N380" corresponds to n°380
* "N381" corresponds to n°381
* "N382" corresponds to n°382
* "N383" corresponds to n°383
* "N384" corresponds to n°384
* "N385" corresponds to n°385
* "N386" corresponds to n°386
* "N387" corresponds to n°387
* "AixBi" corresponds to n°391, WARNING: appears 16 times in the layout
* "AixBi" corresponds to n°395, WARNING: appears 16 times in the layout
* "AixBi" corresponds to n°398, WARNING: appears 16 times in the layout
* "AixBi" corresponds to n°401, WARNING: appears 16 times in the layout
* "N404" corresponds to n°404
* "N405" corresponds to n°405
* "N406" corresponds to n°406
* "N407" corresponds to n°407
* "N408" corresponds to n°408
* "N410" corresponds to n°410
* "N411" corresponds to n°411
* "N412" corresponds to n°412
* "N420" corresponds to n°420
* "N421" corresponds to n°421
* "N423" corresponds to n°423
* "N424" corresponds to n°424
* "N428" corresponds to n°428
* "N429" corresponds to n°429
* "N431" corresponds to n°431
* "N432" corresponds to n°432
* "N440" corresponds to n°440
* "N441" corresponds to n°441
* "N443" corresponds to n°443
* "N444" corresponds to n°444
* "N451" corresponds to n°451
* "N452" corresponds to n°452
* "N454" corresponds to n°454
* "N455" corresponds to n°455
* "N468" corresponds to n°468
* "N469" corresponds to n°469
* "N470" corresponds to n°470
* "N472" corresponds to n°472
* "N477" corresponds to n°477
* "N479" corresponds to n°479
* "N480" corresponds to n°480
* "N481" corresponds to n°481
* "N492" corresponds to n°492
* "N493" corresponds to n°493
* "N495" corresponds to n°495
* "N496" corresponds to n°496
* "N498" corresponds to n°498
* "N499" corresponds to n°499
* "N504" corresponds to n°504
* "N505" corresponds to n°505
* "N513" corresponds to n°513
* "N514" corresponds to n°514
* "N516" corresponds to n°516
* "N517" corresponds to n°517
* "N518" corresponds to n°518
* "N519" corresponds to n°519
* "N528" corresponds to n°528
* "N529" corresponds to n°529
* "N542" corresponds to n°542
* "N543" corresponds to n°543
* "N544" corresponds to n°544
* "N545" corresponds to n°545
* "N546" corresponds to n°546
* "N547" corresponds to n°547
* "N553" corresponds to n°553
* "N554" corresponds to n°554
* "N564" corresponds to n°564
* "N565" corresponds to n°565
* "N567" corresponds to n°567
* "N568" corresponds to n°568
* "N570" corresponds to n°570
* "N571" corresponds to n°571
* "N575" corresponds to n°575
* "N576" corresponds to n°576
* "N586" corresponds to n°586
* "N587" corresponds to n°587
* "N589" corresponds to n°589
* "N590" corresponds to n°590
* "N591" corresponds to n°591
* "N592" corresponds to n°592
* "N597" corresponds to n°597
* "N598" corresponds to n°598
* "N614" corresponds to n°614
* "N615" corresponds to n°615
* "N617" corresponds to n°617
* "N618" corresponds to n°618
* "N620" corresponds to n°620
* "N621" corresponds to n°621
* "N622" corresponds to n°622
* "N625" corresponds to n°625
* "N636" corresponds to n°636
* "N637" corresponds to n°637
* "N639" corresponds to n°639
* "N640" corresponds to n°640
* "N642" corresponds to n°642
* "N643" corresponds to n°643
* "N645" corresponds to n°645
* "N646" corresponds to n°646
* "N659" corresponds to n°659
* "N660" corresponds to n°660
* "N662" corresponds to n°662
* "N663" corresponds to n°663
* "N664" corresponds to n°664
* "N665" corresponds to n°665
* "N666" corresponds to n°666
* "N667" corresponds to n°667
* "N688" corresponds to n°688
* "N689" corresponds to n°689
* "N690" corresponds to n°690
* "N691" corresponds to n°691
* "N692" corresponds to n°692
* "N693" corresponds to n°693
* "N694" corresponds to n°694
* "N695" corresponds to n°695
* "A0" corresponds to n°709
* "B3" corresponds to n°710, WARNING: appears 3 times in the layout
* "B2" corresponds to n°711, WARNING: appears 2 times in the layout
* "B0" corresponds to n°712
* "A2" corresponds to n°714
* "B1" corresponds to n°717
* "A1" corresponds to n°718
* "N720" corresponds to n°720
* "N721" corresponds to n°721
* "N722" corresponds to n°722
* "N723" corresponds to n°723
* "N724" corresponds to n°724
* "A3" corresponds to n°725, WARNING: appears 4 times in the layout
* "N726" corresponds to n°726
* "N728" corresponds to n°728
* "N729" corresponds to n°729
* "N730" corresponds to n°730
* "N731" corresponds to n°731
*
* MOS devices
MN1 0 12 2 0 N1  W=0.128U L=0.008U
MN2 420 27 7 0 N1  W=0.128U L=0.008U
MN3 421 60 420 0 N1  W=0.128U L=0.008U
MN4 0 28 421 0 N1  W=0.128U L=0.008U
MN5 0 14 3 0 N1  W=0.128U L=0.008U
MN6 423 30 9 0 N1  W=0.128U L=0.008U
MN7 424 61 423 0 N1  W=0.128U L=0.008U
MN8 0 31 424 0 N1  W=0.128U L=0.008U
MN9 0 20 5 0 N1  W=0.128U L=0.008U
MN10 428 40 16 0 N1  W=0.128U L=0.008U
MN11 429 69 428 0 N1  W=0.128U L=0.008U
MN12 0 41 429 0 N1  W=0.128U L=0.008U
MN13 0 22 8 0 N1  W=0.128U L=0.008U
MN14 431 44 17 0 N1  W=0.128U L=0.008U
MN15 432 71 431 0 N1  W=0.128U L=0.008U
MN16 0 45 432 0 N1  W=0.128U L=0.008U
MN17 21 0 12 0 N1  W=0.128U L=0.008U
MN18 23 0 14 0 N1  W=0.128U L=0.008U
MN19 24 32 12 0 N1  W=0.128U L=0.008U
MN20 25 33 14 0 N1  W=0.128U L=0.008U
MN21 26 111 20 0 N1  W=0.128U L=0.008U
MN22 29 0 22 0 N1  W=0.128U L=0.008U
MN23 35 47 20 0 N1  W=0.128U L=0.008U
MN24 37 49 22 0 N1  W=0.128U L=0.008U
MN25 0 21 24 0 N1  W=0.128U L=0.008U
MN26 0 23 25 0 N1  W=0.128U L=0.008U
MN27 440 0 27 0 N1  W=0.128U L=0.008U
MN28 441 0 0 0 N1  W=0.128U L=0.008U
MN29 443 0 30 0 N1  W=0.128U L=0.008U
MN30 444 0 0 0 N1  W=0.128U L=0.008U
MN31 0 0 32 0 N1  W=0.128U L=0.008U
MN32 0 0 33 0 N1  W=0.128U L=0.008U
MN33 0 26 35 0 N1  W=0.128U L=0.008U
MN34 0 29 37 0 N1  W=0.128U L=0.008U
MN35 0 81 440 0 N1  W=0.128U L=0.008U
MN36 28 72 441 0 N1  W=0.128U L=0.008U
MN37 451 111 40 0 N1  W=0.128U L=0.008U
MN38 452 111 0 0 N1  W=0.128U L=0.008U
MN39 0 0 443 0 N1  W=0.128U L=0.008U
MN40 31 76 444 0 N1  W=0.128U L=0.008U
MN41 454 0 44 0 N1  W=0.128U L=0.008U
MN42 455 0 0 0 N1  W=0.128U L=0.008U
MN43 0 111 47 0 N1  W=0.128U L=0.008U
MN44 0 0 49 0 N1  W=0.128U L=0.008U
MN45 0 64 21 0 N1  W=0.128U L=0.008U
MN46 0 66 23 0 N1  W=0.128U L=0.008U
MN47 0 0 451 0 N1  W=0.128U L=0.008U
MN48 41 86 452 0 N1  W=0.128U L=0.008U
MN49 0 95 454 0 N1  W=0.128U L=0.008U
MN50 45 90 455 0 N1  W=0.128U L=0.008U
MN51 0 80 26 0 N1  W=0.128U L=0.008U
MN52 0 82 29 0 N1  W=0.128U L=0.008U
MN53 468 72 60 0 N1  W=0.128U L=0.008U
MN54 469 76 61 0 N1  W=0.128U L=0.008U
MN55 0 62 72 0 N1  W=0.128U L=0.008U
MN56 0 63 76 0 N1  W=0.128U L=0.008U
MN57 470 712 0 0 N1  W=0.128U L=0.008U
MN58 472 712 0 0 N1  W=0.128U L=0.008U
MN59 81 72 64 0 N1  W=0.128U L=0.008U
MN60 0 76 66 0 N1  W=0.128U L=0.008U
MN61 0 81 468 0 N1  W=0.128U L=0.008U
MN62 477 86 69 0 N1  W=0.128U L=0.008U
MN63 0 0 469 0 N1  W=0.128U L=0.008U
MN64 89 96 64 0 N1  W=0.128U L=0.008U
MN65 479 90 71 0 N1  W=0.128U L=0.008U
MN66 0 75 86 0 N1  W=0.128U L=0.008U
MN67 93 97 66 0 N1  W=0.128U L=0.008U
MN68 62 718 470 0 N1  W=0.128U L=0.008U
MN69 0 79 90 0 N1  W=0.128U L=0.008U
MN70 480 712 0 0 N1  W=0.128U L=0.008U
MN71 63 709 472 0 N1  W=0.128U L=0.008U
MN72 481 712 0 0 N1  W=0.128U L=0.008U
MN73 0 86 80 0 N1  W=0.128U L=0.008U
MN74 95 90 82 0 N1  W=0.128U L=0.008U
MN75 0 0 477 0 N1  W=0.128U L=0.008U
MN76 0 95 479 0 N1  W=0.128U L=0.008U
MN77 99 103 80 0 N1  W=0.128U L=0.008U
MN78 101 105 82 0 N1  W=0.128U L=0.008U
MN79 75 725 480 0 N1  W=0.128U L=0.008U
MN80 0 81 89 0 N1  W=0.128U L=0.008U
MN81 79 714 481 0 N1  W=0.128U L=0.008U
MN82 0 0 93 0 N1  W=0.128U L=0.008U
MN83 0 72 96 0 N1  W=0.128U L=0.008U
MN84 0 76 97 0 N1  W=0.128U L=0.008U
MN85 0 0 99 0 N1  W=0.128U L=0.008U
MN86 0 95 101 0 N1  W=0.128U L=0.008U
MN87 0 86 103 0 N1  W=0.128U L=0.008U
MN88 0 90 105 0 N1  W=0.128U L=0.008U
MN89 0 119 95 0 N1  W=0.128U L=0.008U
MN90 492 133 113 0 N1  W=0.128U L=0.008U
MN91 493 167 492 0 N1  W=0.128U L=0.008U
MN92 0 134 493 0 N1  W=0.128U L=0.008U
MN93 0 122 110 0 N1  W=0.128U L=0.008U
MN94 495 136 116 0 N1  W=0.128U L=0.008U
MN95 496 168 495 0 N1  W=0.128U L=0.008U
MN96 0 137 496 0 N1  W=0.128U L=0.008U
MN97 0 123 111 0 N1  W=0.128U L=0.008U
MN98 498 139 117 0 N1  W=0.128U L=0.008U
MN99 499 170 498 0 N1  W=0.128U L=0.008U
MN100 0 140 499 0 N1  W=0.128U L=0.008U
MN101 0 129 81 0 N1  W=0.128U L=0.008U
MN102 504 154 125 0 N1  W=0.128U L=0.008U
MN103 505 183 504 0 N1  W=0.128U L=0.008U
MN104 0 155 505 0 N1  W=0.128U L=0.008U
MN105 126 7 119 0 N1  W=0.128U L=0.008U
MN106 128 215 122 0 N1  W=0.128U L=0.008U
MN107 130 17 123 0 N1  W=0.128U L=0.008U
MN108 131 141 119 0 N1  W=0.128U L=0.008U
MN109 132 143 122 0 N1  W=0.128U L=0.008U
MN110 135 144 123 0 N1  W=0.128U L=0.008U
MN111 138 0 129 0 N1  W=0.128U L=0.008U
MN112 0 126 131 0 N1  W=0.128U L=0.008U
MN113 149 159 129 0 N1  W=0.128U L=0.008U
MN114 0 128 132 0 N1  W=0.128U L=0.008U
MN115 513 7 133 0 N1  W=0.128U L=0.008U
MN116 514 7 0 0 N1  W=0.128U L=0.008U
MN117 0 130 135 0 N1  W=0.128U L=0.008U
MN118 516 215 136 0 N1  W=0.128U L=0.008U
MN119 517 215 0 0 N1  W=0.128U L=0.008U
MN120 518 17 139 0 N1  W=0.128U L=0.008U
MN121 519 17 0 0 N1  W=0.128U L=0.008U
MN122 0 7 141 0 N1  W=0.128U L=0.008U
MN123 0 215 143 0 N1  W=0.128U L=0.008U
MN124 0 17 144 0 N1  W=0.128U L=0.008U
MN125 0 187 513 0 N1  W=0.128U L=0.008U
MN126 134 179 514 0 N1  W=0.128U L=0.008U
MN127 0 138 149 0 N1  W=0.128U L=0.008U
MN128 0 16 516 0 N1  W=0.128U L=0.008U
MN129 137 184 517 0 N1  W=0.128U L=0.008U
MN130 0 193 518 0 N1  W=0.128U L=0.008U
MN131 140 188 519 0 N1  W=0.128U L=0.008U
MN132 528 0 154 0 N1  W=0.128U L=0.008U
MN133 529 0 0 0 N1  W=0.128U L=0.008U
MN134 0 171 126 0 N1  W=0.128U L=0.008U
MN135 0 0 159 0 N1  W=0.128U L=0.008U
MN136 0 174 128 0 N1  W=0.128U L=0.008U
MN137 0 175 130 0 N1  W=0.128U L=0.008U
MN138 0 9 528 0 N1  W=0.128U L=0.008U
MN139 155 197 529 0 N1  W=0.128U L=0.008U
MN140 0 192 138 0 N1  W=0.128U L=0.008U
MN141 542 179 167 0 N1  W=0.128U L=0.008U
MN142 0 169 179 0 N1  W=0.128U L=0.008U
MN143 543 184 168 0 N1  W=0.128U L=0.008U
MN144 544 717 0 0 N1  W=0.128U L=0.008U
MN145 545 188 170 0 N1  W=0.128U L=0.008U
MN146 0 172 184 0 N1  W=0.128U L=0.008U
MN147 187 179 171 0 N1  W=0.128U L=0.008U
MN148 0 173 188 0 N1  W=0.128U L=0.008U
MN149 546 717 0 0 N1  W=0.128U L=0.008U
MN150 547 717 0 0 N1  W=0.128U L=0.008U
MN151 16 184 174 0 N1  W=0.128U L=0.008U
MN152 193 188 175 0 N1  W=0.128U L=0.008U
MN153 0 187 542 0 N1  W=0.128U L=0.008U
MN154 195 201 171 0 N1  W=0.128U L=0.008U
MN155 0 16 543 0 N1  W=0.128U L=0.008U
MN156 169 718 544 0 N1  W=0.128U L=0.008U
MN157 0 193 545 0 N1  W=0.128U L=0.008U
MN158 196 203 174 0 N1  W=0.128U L=0.008U
MN159 553 197 183 0 N1  W=0.128U L=0.008U
MN160 200 204 175 0 N1  W=0.128U L=0.008U
MN161 172 725 546 0 N1  W=0.128U L=0.008U
MN162 0 191 197 0 N1  W=0.128U L=0.008U
MN163 173 714 547 0 N1  W=0.128U L=0.008U
MN164 554 717 0 0 N1  W=0.128U L=0.008U
MN165 9 197 192 0 N1  W=0.128U L=0.008U
MN166 0 9 553 0 N1  W=0.128U L=0.008U
MN167 0 187 195 0 N1  W=0.128U L=0.008U
MN168 207 211 192 0 N1  W=0.128U L=0.008U
MN169 0 16 196 0 N1  W=0.128U L=0.008U
MN170 191 709 554 0 N1  W=0.128U L=0.008U
MN171 0 193 200 0 N1  W=0.128U L=0.008U
MN172 0 179 201 0 N1  W=0.128U L=0.008U
MN173 0 184 203 0 N1  W=0.128U L=0.008U
MN174 0 188 204 0 N1  W=0.128U L=0.008U
MN175 0 9 207 0 N1  W=0.128U L=0.008U
MN176 0 197 211 0 N1  W=0.128U L=0.008U
MN177 0 224 193 0 N1  W=0.128U L=0.008U
MN178 564 238 217 0 N1  W=0.128U L=0.008U
MN179 565 271 564 0 N1  W=0.128U L=0.008U
MN180 0 239 565 0 N1  W=0.128U L=0.008U
MN181 0 228 214 0 N1  W=0.128U L=0.008U
MN182 567 241 220 0 N1  W=0.128U L=0.008U
MN183 568 272 567 0 N1  W=0.128U L=0.008U
MN184 0 242 568 0 N1  W=0.128U L=0.008U
MN185 0 229 215 0 N1  W=0.128U L=0.008U
MN186 570 243 221 0 N1  W=0.128U L=0.008U
MN187 571 274 570 0 N1  W=0.128U L=0.008U
MN188 0 244 571 0 N1  W=0.128U L=0.008U
MN189 0 231 187 0 N1  W=0.128U L=0.008U
MN190 575 251 226 0 N1  W=0.128U L=0.008U
MN191 576 281 575 0 N1  W=0.128U L=0.008U
MN192 0 252 576 0 N1  W=0.128U L=0.008U
MN193 232 726 224 0 N1  W=0.128U L=0.008U
MN194 233 319 228 0 N1  W=0.128U L=0.008U
MN195 234 720 229 0 N1  W=0.128U L=0.008U
MN196 235 245 224 0 N1  W=0.128U L=0.008U
MN197 237 248 228 0 N1  W=0.128U L=0.008U
MN198 236 0 231 0 N1  W=0.128U L=0.008U
MN199 240 249 229 0 N1  W=0.128U L=0.008U
MN200 246 260 231 0 N1  W=0.128U L=0.008U
MN201 0 232 235 0 N1  W=0.128U L=0.008U
MN202 0 233 237 0 N1  W=0.128U L=0.008U
MN203 586 726 238 0 N1  W=0.128U L=0.008U
MN204 587 726 0 0 N1  W=0.128U L=0.008U
MN205 0 234 240 0 N1  W=0.128U L=0.008U
MN206 589 319 241 0 N1  W=0.128U L=0.008U
MN207 590 319 0 0 N1  W=0.128U L=0.008U
MN208 591 720 243 0 N1  W=0.128U L=0.008U
MN209 592 720 0 0 N1  W=0.128U L=0.008U
MN210 0 726 245 0 N1  W=0.128U L=0.008U
MN211 0 236 246 0 N1  W=0.128U L=0.008U
MN212 0 319 248 0 N1  W=0.128U L=0.008U
MN213 0 720 249 0 N1  W=0.128U L=0.008U
MN214 597 0 251 0 N1  W=0.128U L=0.008U
MN215 598 0 0 0 N1  W=0.128U L=0.008U
MN216 0 293 586 0 N1  W=0.128U L=0.008U
MN217 239 285 587 0 N1  W=0.128U L=0.008U
MN218 0 116 589 0 N1  W=0.128U L=0.008U
MN219 242 290 590 0 N1  W=0.128U L=0.008U
MN220 0 298 591 0 N1  W=0.128U L=0.008U
MN221 244 294 592 0 N1  W=0.128U L=0.008U
MN222 0 0 260 0 N1  W=0.128U L=0.008U
MN223 0 276 232 0 N1  W=0.128U L=0.008U
MN224 0 125 597 0 N1  W=0.128U L=0.008U
MN225 252 299 598 0 N1  W=0.128U L=0.008U
MN226 0 279 233 0 N1  W=0.128U L=0.008U
MN227 0 280 234 0 N1  W=0.128U L=0.008U
MN228 0 289 236 0 N1  W=0.128U L=0.008U
MN229 614 285 271 0 N1  W=0.128U L=0.008U
MN230 0 273 285 0 N1  W=0.128U L=0.008U
MN231 615 290 272 0 N1  W=0.128U L=0.008U
MN232 617 711 0 0 N1  W=0.128U L=0.008U
MN233 618 294 274 0 N1  W=0.128U L=0.008U
MN234 0 277 290 0 N1  W=0.128U L=0.008U
MN235 293 285 276 0 N1  W=0.128U L=0.008U
MN236 0 278 294 0 N1  W=0.128U L=0.008U
MN237 620 711 0 0 N1  W=0.128U L=0.008U
MN238 621 711 0 0 N1  W=0.128U L=0.008U
MN239 116 290 279 0 N1  W=0.128U L=0.008U
MN240 298 294 280 0 N1  W=0.128U L=0.008U
MN241 622 299 281 0 N1  W=0.128U L=0.008U
MN242 0 293 614 0 N1  W=0.128U L=0.008U
MN243 0 284 299 0 N1  W=0.128U L=0.008U
MN244 302 305 276 0 N1  W=0.128U L=0.008U
MN245 0 116 615 0 N1  W=0.128U L=0.008U
MN246 625 711 0 0 N1  W=0.128U L=0.008U
MN247 273 718 617 0 N1  W=0.128U L=0.008U
MN248 0 298 618 0 N1  W=0.128U L=0.008U
MN249 303 308 279 0 N1  W=0.128U L=0.008U
MN250 125 299 289 0 N1  W=0.128U L=0.008U
MN251 304 309 280 0 N1  W=0.128U L=0.008U
MN252 277 725 620 0 N1  W=0.128U L=0.008U
MN253 278 714 621 0 N1  W=0.128U L=0.008U
MN254 0 125 622 0 N1  W=0.128U L=0.008U
MN255 306 312 289 0 N1  W=0.128U L=0.008U
MN256 284 709 625 0 N1  W=0.128U L=0.008U
MN257 0 293 302 0 N1  W=0.128U L=0.008U
MN258 0 116 303 0 N1  W=0.128U L=0.008U
MN259 0 298 304 0 N1  W=0.128U L=0.008U
MN260 0 285 305 0 N1  W=0.128U L=0.008U
MN261 0 125 306 0 N1  W=0.128U L=0.008U
MN262 0 290 308 0 N1  W=0.128U L=0.008U
MN263 0 294 309 0 N1  W=0.128U L=0.008U
MN264 0 299 312 0 N1  W=0.128U L=0.008U
MN265 0 329 298 0 N1  W=0.128U L=0.008U
MN266 636 343 321 0 N1  W=0.128U L=0.008U
MN267 637 376 636 0 N1  W=0.128U L=0.008U
MN268 0 344 637 0 N1  W=0.128U L=0.008U
MN269 0 333 318 0 N1  W=0.128U L=0.008U
MN270 639 346 325 0 N1  W=0.128U L=0.008U
MN271 640 377 639 0 N1  W=0.128U L=0.008U
MN272 0 347 640 0 N1  W=0.128U L=0.008U
MN273 0 334 293 0 N1  W=0.128U L=0.008U
MN274 642 348 326 0 N1  W=0.128U L=0.008U
MN275 643 378 642 0 N1  W=0.128U L=0.008U
MN276 0 349 643 0 N1  W=0.128U L=0.008U
MN277 0 335 319 0 N1  W=0.128U L=0.008U
MN278 645 350 327 0 N1  W=0.128U L=0.008U
MN279 646 380 645 0 N1  W=0.128U L=0.008U
MN280 0 351 646 0 N1  W=0.128U L=0.008U
MN281 336 326 329 0 N1  W=0.128U L=0.008U
MN282 337 327 333 0 N1  W=0.128U L=0.008U
MN283 338 0 334 0 N1  W=0.128U L=0.008U
MN284 339 321 335 0 N1  W=0.128U L=0.008U
MN285 340 352 329 0 N1  W=0.128U L=0.008U
MN286 341 354 333 0 N1  W=0.128U L=0.008U
MN287 342 355 334 0 N1  W=0.128U L=0.008U
MN288 345 356 335 0 N1  W=0.128U L=0.008U
MN289 0 336 340 0 N1  W=0.128U L=0.008U
MN290 0 337 341 0 N1  W=0.128U L=0.008U
MN291 0 338 342 0 N1  W=0.128U L=0.008U
MN292 659 326 343 0 N1  W=0.128U L=0.008U
MN293 660 326 0 0 N1  W=0.128U L=0.008U
MN294 0 339 345 0 N1  W=0.128U L=0.008U
MN295 662 327 346 0 N1  W=0.128U L=0.008U
MN296 663 327 0 0 N1  W=0.128U L=0.008U
MN297 664 0 348 0 N1  W=0.128U L=0.008U
MN298 665 0 0 0 N1  W=0.128U L=0.008U
MN299 666 321 350 0 N1  W=0.128U L=0.008U
MN300 667 321 0 0 N1  W=0.128U L=0.008U
MN301 0 326 352 0 N1  W=0.128U L=0.008U
MN302 0 327 354 0 N1  W=0.128U L=0.008U
MN303 0 0 355 0 N1  W=0.128U L=0.008U
MN304 0 321 356 0 N1  W=0.128U L=0.008U
MN305 0 217 659 0 N1  W=0.128U L=0.008U
MN306 344 391 660 0 N1  W=0.128U L=0.008U
MN307 0 220 662 0 N1  W=0.128U L=0.008U
MN308 347 395 663 0 N1  W=0.128U L=0.008U
MN309 0 226 664 0 N1  W=0.128U L=0.008U
MN310 349 398 665 0 N1  W=0.128U L=0.008U
MN311 0 221 666 0 N1  W=0.128U L=0.008U
MN312 351 401 667 0 N1  W=0.128U L=0.008U
MN313 0 381 336 0 N1  W=0.128U L=0.008U
MN314 0 385 337 0 N1  W=0.128U L=0.008U
MN315 0 386 338 0 N1  W=0.128U L=0.008U
MN316 0 387 339 0 N1  W=0.128U L=0.008U
MN317 688 391 376 0 N1  W=0.128U L=0.008U
MN318 0 379 391 0 N1  W=0.128U L=0.008U
MN319 689 395 377 0 N1  W=0.128U L=0.008U
MN320 690 398 378 0 N1  W=0.128U L=0.008U
MN321 691 710 0 0 N1  W=0.128U L=0.008U
MN322 692 401 380 0 N1  W=0.128U L=0.008U
MN323 0 382 395 0 N1  W=0.128U L=0.008U
MN324 0 383 398 0 N1  W=0.128U L=0.008U
MN325 217 391 381 0 N1  W=0.128U L=0.008U
MN326 0 384 401 0 N1  W=0.128U L=0.008U
MN327 693 710 0 0 N1  W=0.128U L=0.008U
MN328 694 710 0 0 N1  W=0.128U L=0.008U
MN329 695 710 0 0 N1  W=0.128U L=0.008U
MN330 220 395 385 0 N1  W=0.128U L=0.008U
MN331 226 398 386 0 N1  W=0.128U L=0.008U
MN332 221 401 387 0 N1  W=0.128U L=0.008U
MN333 0 217 688 0 N1  W=0.128U L=0.008U
MN334 404 408 381 0 N1  W=0.128U L=0.008U
MN335 0 220 689 0 N1  W=0.128U L=0.008U
MN336 0 226 690 0 N1  W=0.128U L=0.008U
MN337 379 718 691 0 N1  W=0.128U L=0.008U
MN338 0 221 692 0 N1  W=0.128U L=0.008U
MN339 405 410 385 0 N1  W=0.128U L=0.008U
MN340 406 411 386 0 N1  W=0.128U L=0.008U
MN341 407 412 387 0 N1  W=0.128U L=0.008U
MN342 382 725 693 0 N1  W=0.128U L=0.008U
MN343 383 709 694 0 N1  W=0.128U L=0.008U
MN344 384 714 695 0 N1  W=0.128U L=0.008U
MN345 0 217 404 0 N1  W=0.128U L=0.008U
MN346 0 220 405 0 N1  W=0.128U L=0.008U
MN347 0 226 406 0 N1  W=0.128U L=0.008U
MN348 0 221 407 0 N1  W=0.128U L=0.008U
MN349 0 391 408 0 N1  W=0.128U L=0.008U
MN350 0 395 410 0 N1  W=0.128U L=0.008U
MN351 0 398 411 0 N1  W=0.128U L=0.008U
MN352 0 401 412 0 N1  W=0.128U L=0.008U
MP1 1 12 2 1 P1  W=0.128U L=0.008U
MP2 1 14 3 1 P1  W=0.128U L=0.008U
MP3 1 20 5 1 P1  W=0.128U L=0.008U
MP4 1 22 8 1 P1  W=0.128U L=0.008U
MP5 7 27 1 1 P1  W=0.128U L=0.008U
MP6 1 60 7 1 P1  W=0.128U L=0.008U
MP7 7 28 1 1 P1  W=0.128U L=0.008U
MP8 9 30 1 1 P1  W=0.128U L=0.008U
MP9 1 61 9 1 P1  W=0.128U L=0.008U
MP10 9 31 1 1 P1  W=0.128U L=0.008U
MP11 21 32 12 1 P1  W=0.128U L=0.008U
MP12 23 33 14 1 P1  W=0.128U L=0.008U
MP13 16 40 1 1 P1  W=0.128U L=0.008U
MP14 1 69 16 1 P1  W=0.128U L=0.008U
MP15 16 41 1 1 P1  W=0.128U L=0.008U
MP16 24 0 12 1 P1  W=0.128U L=0.008U
MP17 17 44 1 1 P1  W=0.128U L=0.008U
MP18 1 71 17 1 P1  W=0.128U L=0.008U
MP19 17 45 1 1 P1  W=0.128U L=0.008U
MP20 25 0 14 1 P1  W=0.128U L=0.008U
MP21 26 47 20 1 P1  W=0.128U L=0.008U
MP22 29 49 22 1 P1  W=0.128U L=0.008U
MP23 35 111 20 1 P1  W=0.128U L=0.008U
MP24 37 0 22 1 P1  W=0.128U L=0.008U
MP25 1 21 24 1 P1  W=0.128U L=0.008U
MP26 1 23 25 1 P1  W=0.128U L=0.008U
MP27 1 0 27 1 P1  W=0.128U L=0.008U
MP28 1 0 28 1 P1  W=0.128U L=0.008U
MP29 1 0 30 1 P1  W=0.128U L=0.008U
MP30 1 0 31 1 P1  W=0.128U L=0.008U
MP31 1 0 32 1 P1  W=0.128U L=0.008U
MP32 1 0 33 1 P1  W=0.128U L=0.008U
MP33 1 26 35 1 P1  W=0.128U L=0.008U
MP34 1 29 37 1 P1  W=0.128U L=0.008U
MP35 27 81 1 1 P1  W=0.128U L=0.008U
MP36 28 72 1 1 P1  W=0.128U L=0.008U
MP37 1 111 40 1 P1  W=0.128U L=0.008U
MP38 1 111 41 1 P1  W=0.128U L=0.008U
MP39 30 0 1 1 P1  W=0.128U L=0.008U
MP40 31 76 1 1 P1  W=0.128U L=0.008U
MP41 1 0 44 1 P1  W=0.128U L=0.008U
MP42 1 0 45 1 P1  W=0.128U L=0.008U
MP43 1 111 47 1 P1  W=0.128U L=0.008U
MP44 1 0 49 1 P1  W=0.128U L=0.008U
MP45 1 64 21 1 P1  W=0.128U L=0.008U
MP46 1 66 23 1 P1  W=0.128U L=0.008U
MP47 40 0 1 1 P1  W=0.128U L=0.008U
MP48 41 86 1 1 P1  W=0.128U L=0.008U
MP49 44 95 1 1 P1  W=0.128U L=0.008U
MP50 45 90 1 1 P1  W=0.128U L=0.008U
MP51 1 80 26 1 P1  W=0.128U L=0.008U
MP52 1 82 29 1 P1  W=0.128U L=0.008U
MP53 1 72 60 1 P1  W=0.128U L=0.008U
MP54 1 76 61 1 P1  W=0.128U L=0.008U
MP55 1 712 62 1 P1  W=0.128U L=0.008U
MP56 1 712 63 1 P1  W=0.128U L=0.008U
MP57 81 96 64 1 P1  W=0.128U L=0.008U
MP58 0 97 66 1 P1  W=0.128U L=0.008U
MP59 1 62 72 1 P1  W=0.128U L=0.008U
MP60 60 81 1 1 P1  W=0.128U L=0.008U
MP61 1 86 69 1 P1  W=0.128U L=0.008U
MP62 1 63 76 1 P1  W=0.128U L=0.008U
MP63 61 0 1 1 P1  W=0.128U L=0.008U
MP64 89 72 64 1 P1  W=0.128U L=0.008U
MP65 1 90 71 1 P1  W=0.128U L=0.008U
MP66 93 76 66 1 P1  W=0.128U L=0.008U
MP67 62 718 1 1 P1  W=0.128U L=0.008U
MP68 1 712 75 1 P1  W=0.128U L=0.008U
MP69 63 709 1 1 P1  W=0.128U L=0.008U
MP70 1 712 79 1 P1  W=0.128U L=0.008U
MP71 0 103 80 1 P1  W=0.128U L=0.008U
MP72 95 105 82 1 P1  W=0.128U L=0.008U
MP73 1 75 86 1 P1  W=0.128U L=0.008U
MP74 69 0 1 1 P1  W=0.128U L=0.008U
MP75 1 79 90 1 P1  W=0.128U L=0.008U
MP76 71 95 1 1 P1  W=0.128U L=0.008U
MP77 99 86 80 1 P1  W=0.128U L=0.008U
MP78 101 90 82 1 P1  W=0.128U L=0.008U
MP79 75 725 1 1 P1  W=0.128U L=0.008U
MP80 1 81 89 1 P1  W=0.128U L=0.008U
MP81 79 714 1 1 P1  W=0.128U L=0.008U
MP82 1 0 93 1 P1  W=0.128U L=0.008U
MP83 1 72 96 1 P1  W=0.128U L=0.008U
MP84 1 76 97 1 P1  W=0.128U L=0.008U
MP85 1 0 99 1 P1  W=0.128U L=0.008U
MP86 1 95 101 1 P1  W=0.128U L=0.008U
MP87 1 86 103 1 P1  W=0.128U L=0.008U
MP88 1 90 105 1 P1  W=0.128U L=0.008U
MP89 1 119 95 1 P1  W=0.128U L=0.008U
MP90 1 122 110 1 P1  W=0.128U L=0.008U
MP91 1 123 111 1 P1  W=0.128U L=0.008U
MP92 1 129 81 1 P1  W=0.128U L=0.008U
MP93 113 133 1 1 P1  W=0.128U L=0.008U
MP94 1 167 113 1 P1  W=0.128U L=0.008U
MP95 113 134 1 1 P1  W=0.128U L=0.008U
MP96 116 136 1 1 P1  W=0.128U L=0.008U
MP97 1 168 116 1 P1  W=0.128U L=0.008U
MP98 116 137 1 1 P1  W=0.128U L=0.008U
MP99 117 139 1 1 P1  W=0.128U L=0.008U
MP100 1 170 117 1 P1  W=0.128U L=0.008U
MP101 117 140 1 1 P1  W=0.128U L=0.008U
MP102 126 141 119 1 P1  W=0.128U L=0.008U
MP103 128 143 122 1 P1  W=0.128U L=0.008U
MP104 130 144 123 1 P1  W=0.128U L=0.008U
MP105 131 7 119 1 P1  W=0.128U L=0.008U
MP106 132 215 122 1 P1  W=0.128U L=0.008U
MP107 125 154 1 1 P1  W=0.128U L=0.008U
MP108 1 183 125 1 P1  W=0.128U L=0.008U
MP109 125 155 1 1 P1  W=0.128U L=0.008U
MP110 135 17 123 1 P1  W=0.128U L=0.008U
MP111 138 159 129 1 P1  W=0.128U L=0.008U
MP112 1 126 131 1 P1  W=0.128U L=0.008U
MP113 149 0 129 1 P1  W=0.128U L=0.008U
MP114 1 128 132 1 P1  W=0.128U L=0.008U
MP115 1 7 133 1 P1  W=0.128U L=0.008U
MP116 1 7 134 1 P1  W=0.128U L=0.008U
MP117 1 130 135 1 P1  W=0.128U L=0.008U
MP118 1 215 136 1 P1  W=0.128U L=0.008U
MP119 1 215 137 1 P1  W=0.128U L=0.008U
MP120 1 17 139 1 P1  W=0.128U L=0.008U
MP121 1 17 140 1 P1  W=0.128U L=0.008U
MP122 1 7 141 1 P1  W=0.128U L=0.008U
MP123 1 215 143 1 P1  W=0.128U L=0.008U
MP124 1 17 144 1 P1  W=0.128U L=0.008U
MP125 133 187 1 1 P1  W=0.128U L=0.008U
MP126 134 179 1 1 P1  W=0.128U L=0.008U
MP127 1 138 149 1 P1  W=0.128U L=0.008U
MP128 136 16 1 1 P1  W=0.128U L=0.008U
MP129 137 184 1 1 P1  W=0.128U L=0.008U
MP130 139 193 1 1 P1  W=0.128U L=0.008U
MP131 140 188 1 1 P1  W=0.128U L=0.008U
MP132 1 0 154 1 P1  W=0.128U L=0.008U
MP133 1 0 155 1 P1  W=0.128U L=0.008U
MP134 1 171 126 1 P1  W=0.128U L=0.008U
MP135 1 0 159 1 P1  W=0.128U L=0.008U
MP136 1 174 128 1 P1  W=0.128U L=0.008U
MP137 1 175 130 1 P1  W=0.128U L=0.008U
MP138 154 9 1 1 P1  W=0.128U L=0.008U
MP139 155 197 1 1 P1  W=0.128U L=0.008U
MP140 1 192 138 1 P1  W=0.128U L=0.008U
MP141 1 179 167 1 P1  W=0.128U L=0.008U
MP142 1 184 168 1 P1  W=0.128U L=0.008U
MP143 1 717 169 1 P1  W=0.128U L=0.008U
MP144 1 188 170 1 P1  W=0.128U L=0.008U
MP145 187 201 171 1 P1  W=0.128U L=0.008U
MP146 1 717 172 1 P1  W=0.128U L=0.008U
MP147 1 717 173 1 P1  W=0.128U L=0.008U
MP148 16 203 174 1 P1  W=0.128U L=0.008U
MP149 193 204 175 1 P1  W=0.128U L=0.008U
MP150 1 169 179 1 P1  W=0.128U L=0.008U
MP151 167 187 1 1 P1  W=0.128U L=0.008U
MP152 195 179 171 1 P1  W=0.128U L=0.008U
MP153 1 172 184 1 P1  W=0.128U L=0.008U
MP154 168 16 1 1 P1  W=0.128U L=0.008U
MP155 169 718 1 1 P1  W=0.128U L=0.008U
MP156 1 173 188 1 P1  W=0.128U L=0.008U
MP157 170 193 1 1 P1  W=0.128U L=0.008U
MP158 196 184 174 1 P1  W=0.128U L=0.008U
MP159 1 197 183 1 P1  W=0.128U L=0.008U
MP160 200 188 175 1 P1  W=0.128U L=0.008U
MP161 172 725 1 1 P1  W=0.128U L=0.008U
MP162 173 714 1 1 P1  W=0.128U L=0.008U
MP163 1 717 191 1 P1  W=0.128U L=0.008U
MP164 9 211 192 1 P1  W=0.128U L=0.008U
MP165 1 191 197 1 P1  W=0.128U L=0.008U
MP166 183 9 1 1 P1  W=0.128U L=0.008U
MP167 1 187 195 1 P1  W=0.128U L=0.008U
MP168 207 197 192 1 P1  W=0.128U L=0.008U
MP169 1 16 196 1 P1  W=0.128U L=0.008U
MP170 191 709 1 1 P1  W=0.128U L=0.008U
MP171 1 193 200 1 P1  W=0.128U L=0.008U
MP172 1 179 201 1 P1  W=0.128U L=0.008U
MP173 1 184 203 1 P1  W=0.128U L=0.008U
MP174 1 188 204 1 P1  W=0.128U L=0.008U
MP175 1 9 207 1 P1  W=0.128U L=0.008U
MP176 1 197 211 1 P1  W=0.128U L=0.008U
MP177 1 224 193 1 P1  W=0.128U L=0.008U
MP178 1 228 214 1 P1  W=0.128U L=0.008U
MP179 1 229 215 1 P1  W=0.128U L=0.008U
MP180 1 231 187 1 P1  W=0.128U L=0.008U
MP181 217 238 1 1 P1  W=0.128U L=0.008U
MP182 1 271 217 1 P1  W=0.128U L=0.008U
MP183 217 239 1 1 P1  W=0.128U L=0.008U
MP184 220 241 1 1 P1  W=0.128U L=0.008U
MP185 1 272 220 1 P1  W=0.128U L=0.008U
MP186 220 242 1 1 P1  W=0.128U L=0.008U
MP187 221 243 1 1 P1  W=0.128U L=0.008U
MP188 1 274 221 1 P1  W=0.128U L=0.008U
MP189 221 244 1 1 P1  W=0.128U L=0.008U
MP190 232 245 224 1 P1  W=0.128U L=0.008U
MP191 233 248 228 1 P1  W=0.128U L=0.008U
MP192 234 249 229 1 P1  W=0.128U L=0.008U
MP193 226 251 1 1 P1  W=0.128U L=0.008U
MP194 1 281 226 1 P1  W=0.128U L=0.008U
MP195 226 252 1 1 P1  W=0.128U L=0.008U
MP196 235 726 224 1 P1  W=0.128U L=0.008U
MP197 237 319 228 1 P1  W=0.128U L=0.008U
MP198 236 260 231 1 P1  W=0.128U L=0.008U
MP199 240 720 229 1 P1  W=0.128U L=0.008U
MP200 246 0 231 1 P1  W=0.128U L=0.008U
MP201 1 232 235 1 P1  W=0.128U L=0.008U
MP202 1 233 237 1 P1  W=0.128U L=0.008U
MP203 1 726 238 1 P1  W=0.128U L=0.008U
MP204 1 726 239 1 P1  W=0.128U L=0.008U
MP205 1 234 240 1 P1  W=0.128U L=0.008U
MP206 1 319 241 1 P1  W=0.128U L=0.008U
MP207 1 319 242 1 P1  W=0.128U L=0.008U
MP208 1 720 243 1 P1  W=0.128U L=0.008U
MP209 1 720 244 1 P1  W=0.128U L=0.008U
MP210 1 726 245 1 P1  W=0.128U L=0.008U
MP211 1 236 246 1 P1  W=0.128U L=0.008U
MP212 1 319 248 1 P1  W=0.128U L=0.008U
MP213 1 720 249 1 P1  W=0.128U L=0.008U
MP214 1 0 251 1 P1  W=0.128U L=0.008U
MP215 1 0 252 1 P1  W=0.128U L=0.008U
MP216 238 293 1 1 P1  W=0.128U L=0.008U
MP217 239 285 1 1 P1  W=0.128U L=0.008U
MP218 241 116 1 1 P1  W=0.128U L=0.008U
MP219 242 290 1 1 P1  W=0.128U L=0.008U
MP220 243 298 1 1 P1  W=0.128U L=0.008U
MP221 244 294 1 1 P1  W=0.128U L=0.008U
MP222 1 0 260 1 P1  W=0.128U L=0.008U
MP223 1 276 232 1 P1  W=0.128U L=0.008U
MP224 251 125 1 1 P1  W=0.128U L=0.008U
MP225 252 299 1 1 P1  W=0.128U L=0.008U
MP226 1 279 233 1 P1  W=0.128U L=0.008U
MP227 1 280 234 1 P1  W=0.128U L=0.008U
MP228 1 289 236 1 P1  W=0.128U L=0.008U
MP229 1 285 271 1 P1  W=0.128U L=0.008U
MP230 1 290 272 1 P1  W=0.128U L=0.008U
MP231 1 711 273 1 P1  W=0.128U L=0.008U
MP232 1 294 274 1 P1  W=0.128U L=0.008U
MP233 293 305 276 1 P1  W=0.128U L=0.008U
MP234 1 711 277 1 P1  W=0.128U L=0.008U
MP235 1 711 278 1 P1  W=0.128U L=0.008U
MP236 116 308 279 1 P1  W=0.128U L=0.008U
MP237 298 309 280 1 P1  W=0.128U L=0.008U
MP238 1 299 281 1 P1  W=0.128U L=0.008U
MP239 1 273 285 1 P1  W=0.128U L=0.008U
MP240 271 293 1 1 P1  W=0.128U L=0.008U
MP241 302 285 276 1 P1  W=0.128U L=0.008U
MP242 1 277 290 1 P1  W=0.128U L=0.008U
MP243 272 116 1 1 P1  W=0.128U L=0.008U
MP244 1 711 284 1 P1  W=0.128U L=0.008U
MP245 273 718 1 1 P1  W=0.128U L=0.008U
MP246 1 278 294 1 P1  W=0.128U L=0.008U
MP247 274 298 1 1 P1  W=0.128U L=0.008U
MP248 303 290 279 1 P1  W=0.128U L=0.008U
MP249 125 312 289 1 P1  W=0.128U L=0.008U
MP250 304 294 280 1 P1  W=0.128U L=0.008U
MP251 277 725 1 1 P1  W=0.128U L=0.008U
MP252 278 714 1 1 P1  W=0.128U L=0.008U
MP253 1 284 299 1 P1  W=0.128U L=0.008U
MP254 281 125 1 1 P1  W=0.128U L=0.008U
MP255 306 299 289 1 P1  W=0.128U L=0.008U
MP256 284 709 1 1 P1  W=0.128U L=0.008U
MP257 1 293 302 1 P1  W=0.128U L=0.008U
MP258 1 116 303 1 P1  W=0.128U L=0.008U
MP259 1 298 304 1 P1  W=0.128U L=0.008U
MP260 1 285 305 1 P1  W=0.128U L=0.008U
MP261 1 125 306 1 P1  W=0.128U L=0.008U
MP262 1 290 308 1 P1  W=0.128U L=0.008U
MP263 1 294 309 1 P1  W=0.128U L=0.008U
MP264 1 299 312 1 P1  W=0.128U L=0.008U
MP265 1 329 298 1 P1  W=0.128U L=0.008U
MP266 1 333 318 1 P1  W=0.128U L=0.008U
MP267 1 334 293 1 P1  W=0.128U L=0.008U
MP268 1 335 319 1 P1  W=0.128U L=0.008U
MP269 321 343 1 1 P1  W=0.128U L=0.008U
MP270 1 376 321 1 P1  W=0.128U L=0.008U
MP271 321 344 1 1 P1  W=0.128U L=0.008U
MP272 325 346 1 1 P1  W=0.128U L=0.008U
MP273 1 377 325 1 P1  W=0.128U L=0.008U
MP274 325 347 1 1 P1  W=0.128U L=0.008U
MP275 326 348 1 1 P1  W=0.128U L=0.008U
MP276 1 378 326 1 P1  W=0.128U L=0.008U
MP277 326 349 1 1 P1  W=0.128U L=0.008U
MP278 327 350 1 1 P1  W=0.128U L=0.008U
MP279 1 380 327 1 P1  W=0.128U L=0.008U
MP280 327 351 1 1 P1  W=0.128U L=0.008U
MP281 336 352 329 1 P1  W=0.128U L=0.008U
MP282 337 354 333 1 P1  W=0.128U L=0.008U
MP283 338 355 334 1 P1  W=0.128U L=0.008U
MP284 339 356 335 1 P1  W=0.128U L=0.008U
MP285 340 326 329 1 P1  W=0.128U L=0.008U
MP286 341 327 333 1 P1  W=0.128U L=0.008U
MP287 342 0 334 1 P1  W=0.128U L=0.008U
MP288 345 321 335 1 P1  W=0.128U L=0.008U
MP289 1 336 340 1 P1  W=0.128U L=0.008U
MP290 1 337 341 1 P1  W=0.128U L=0.008U
MP291 1 338 342 1 P1  W=0.128U L=0.008U
MP292 1 326 343 1 P1  W=0.128U L=0.008U
MP293 1 326 344 1 P1  W=0.128U L=0.008U
MP294 1 339 345 1 P1  W=0.128U L=0.008U
MP295 1 327 346 1 P1  W=0.128U L=0.008U
MP296 1 327 347 1 P1  W=0.128U L=0.008U
MP297 1 0 348 1 P1  W=0.128U L=0.008U
MP298 1 0 349 1 P1  W=0.128U L=0.008U
MP299 1 321 350 1 P1  W=0.128U L=0.008U
MP300 1 321 351 1 P1  W=0.128U L=0.008U
MP301 1 326 352 1 P1  W=0.128U L=0.008U
MP302 1 327 354 1 P1  W=0.128U L=0.008U
MP303 1 0 355 1 P1  W=0.128U L=0.008U
MP304 1 321 356 1 P1  W=0.128U L=0.008U
MP305 343 217 1 1 P1  W=0.128U L=0.008U
MP306 344 391 1 1 P1  W=0.128U L=0.008U
MP307 346 220 1 1 P1  W=0.128U L=0.008U
MP308 347 395 1 1 P1  W=0.128U L=0.008U
MP309 348 226 1 1 P1  W=0.128U L=0.008U
MP310 349 398 1 1 P1  W=0.128U L=0.008U
MP311 350 221 1 1 P1  W=0.128U L=0.008U
MP312 351 401 1 1 P1  W=0.128U L=0.008U
MP313 1 381 336 1 P1  W=0.128U L=0.008U
MP314 1 385 337 1 P1  W=0.128U L=0.008U
MP315 1 386 338 1 P1  W=0.128U L=0.008U
MP316 1 387 339 1 P1  W=0.128U L=0.008U
MP317 1 391 376 1 P1  W=0.128U L=0.008U
MP318 1 395 377 1 P1  W=0.128U L=0.008U
MP319 1 398 378 1 P1  W=0.128U L=0.008U
MP320 1 710 379 1 P1  W=0.128U L=0.008U
MP321 1 401 380 1 P1  W=0.128U L=0.008U
MP322 217 408 381 1 P1  W=0.128U L=0.008U
MP323 1 710 382 1 P1  W=0.128U L=0.008U
MP324 1 710 383 1 P1  W=0.128U L=0.008U
MP325 1 710 384 1 P1  W=0.128U L=0.008U
MP326 220 410 385 1 P1  W=0.128U L=0.008U
MP327 226 411 386 1 P1  W=0.128U L=0.008U
MP328 221 412 387 1 P1  W=0.128U L=0.008U
MP329 1 379 391 1 P1  W=0.128U L=0.008U
MP330 376 217 1 1 P1  W=0.128U L=0.008U
MP331 404 391 381 1 P1  W=0.128U L=0.008U
MP332 1 382 395 1 P1  W=0.128U L=0.008U
MP333 377 220 1 1 P1  W=0.128U L=0.008U
MP334 1 383 398 1 P1  W=0.128U L=0.008U
MP335 378 226 1 1 P1  W=0.128U L=0.008U
MP336 379 718 1 1 P1  W=0.128U L=0.008U
MP337 1 384 401 1 P1  W=0.128U L=0.008U
MP338 380 221 1 1 P1  W=0.128U L=0.008U
MP339 405 395 385 1 P1  W=0.128U L=0.008U
MP340 406 398 386 1 P1  W=0.128U L=0.008U
MP341 407 401 387 1 P1  W=0.128U L=0.008U
MP342 382 725 1 1 P1  W=0.128U L=0.008U
MP343 383 709 1 1 P1  W=0.128U L=0.008U
MP344 384 714 1 1 P1  W=0.128U L=0.008U
MP345 1 217 404 1 P1  W=0.128U L=0.008U
MP346 1 220 405 1 P1  W=0.128U L=0.008U
MP347 1 226 406 1 P1  W=0.128U L=0.008U
MP348 1 221 407 1 P1  W=0.128U L=0.008U
MP349 1 391 408 1 P1  W=0.128U L=0.008U
MP350 1 395 410 1 P1  W=0.128U L=0.008U
MP351 1 398 411 1 P1  W=0.128U L=0.008U
MP352 1 401 412 1 P1  W=0.128U L=0.008U
*
C2 2 0  0.121fF
C3 3 0  0.112fF
C4 1 0  0.005fF
C5 5 0  0.150fF
C6 1 0  0.005fF
C7 7 0  0.591fF
C8 8 0  0.129fF
C9 9 0  0.867fF
C10 1 0  0.059fF
C11 1 0  0.059fF
C12 12 0  0.114fF
C13 1 0  0.005fF
C14 14 0  0.114fF
C15 1 0  0.005fF
C16 16 0  0.763fF
C17 17 0  0.543fF
C18 1 0  0.059fF
C19 1 0  0.059fF
C20 20 0  0.114fF
C21 21 0  0.115fF
C22 22 0  0.114fF
C23 23 0  0.115fF
C24 24 0  0.028fF
C25 25 0  0.028fF
C26 26 0  0.115fF
C27 27 0  0.091fF
C28 28 0  0.112fF
C29 29 0  0.115fF
C30 30 0  0.091fF
C31 31 0  0.112fF
C32 32 0  0.090fF
C33 33 0  0.090fF
C34 1 0  0.005fF
C35 35 0  0.028fF
C36 1 0  0.005fF
C37 37 0  0.028fF
C38 1 0  0.005fF
C39 1 0  0.005fF
C40 40 0  0.091fF
C41 41 0  0.112fF
C42 1 0  0.005fF
C43 1 0  0.005fF
C44 44 0  0.091fF
C45 45 0  0.112fF
C46 1 0  0.005fF
C47 47 0  0.090fF
C48 1 0  0.005fF
C49 49 0  0.090fF
C50 1 0  0.005fF
C51 1 0  0.005fF
C52 1 0  0.005fF
C53 1 0  0.005fF
C54 1 0  0.005fF
C55 1 0  0.005fF
C56 1 0  0.005fF
C57 1 0  0.005fF
C58 1 0  0.005fF
C59 1 0  0.005fF
C60 60 0  0.137fF
C61 61 0  0.137fF
C62 62 0  0.086fF
C63 63 0  0.086fF
C64 64 0  0.114fF
C65 1 0  0.005fF
C66 66 0  0.114fF
C67 1 0  0.005fF
C68 1 0  0.005fF
C69 69 0  0.137fF
C70 1 0  0.005fF
C71 71 0  0.137fF
C72 72 0  0.218fF
C73 1 0  0.005fF
C74 1 0  0.005fF
C75 75 0  0.086fF
C76 76 0  0.218fF
C77 1 0  0.005fF
C78 1 0  0.005fF
C79 79 0  0.086fF
C80 80 0  0.114fF
C81 81 0  0.615fF
C82 82 0  0.114fF
C84 1 0  0.005fF
C85 1 0  0.005fF
C86 86 0  0.218fF
C87 1 0  0.005fF
C88 1 0  0.005fF
C89 89 0  0.028fF
C90 90 0  0.218fF
C91 1 0  0.005fF
C92 1 0  0.005fF
C93 93 0  0.028fF
C95 95 0  0.529fF
C96 96 0  0.090fF
C97 97 0  0.090fF
C98 1 0  0.005fF
C99 99 0  0.028fF
C100 1 0  0.005fF
C101 101 0  0.028fF
C102 1 0  0.005fF
C103 103 0  0.090fF
C104 1 0  0.005fF
C105 105 0  0.090fF
C106 1 0  0.005fF
C107 1 0  0.005fF
C108 1 0  0.005fF
C109 1 0  0.005fF
C110 110 0  0.177fF
C111 111 0  0.491fF
C112 1 0  0.005fF
C113 113 0  0.158fF
C114 1 0  0.005fF
C115 1 0  0.005fF
C116 116 0  0.829fF
C117 117 0  0.158fF
C118 1 0  0.059fF
C119 119 0  0.114fF
C120 1 0  0.059fF
C121 1 0  0.059fF
C122 122 0  0.114fF
C123 123 0  0.114fF
C124 1 0  0.005fF
C125 125 0  0.832fF
C126 126 0  0.115fF
C127 1 0  0.059fF
C128 128 0  0.115fF
C129 129 0  0.114fF
C130 130 0  0.115fF
C131 131 0  0.028fF
C132 132 0  0.028fF
C133 133 0  0.091fF
C134 134 0  0.112fF
C135 135 0  0.028fF
C136 136 0  0.091fF
C137 137 0  0.112fF
C138 138 0  0.115fF
C139 139 0  0.091fF
C140 140 0  0.112fF
C141 141 0  0.090fF
C142 1 0  0.005fF
C143 143 0  0.090fF
C144 144 0  0.090fF
C145 1 0  0.005fF
C146 1 0  0.005fF
C147 1 0  0.005fF
C148 1 0  0.005fF
C149 149 0  0.028fF
C150 1 0  0.005fF
C151 1 0  0.005fF
C152 1 0  0.005fF
C153 1 0  0.005fF
C154 154 0  0.091fF
C155 155 0  0.112fF
C156 1 0  0.005fF
C157 1 0  0.005fF
C158 1 0  0.005fF
C159 159 0  0.090fF
C160 1 0  0.005fF
C161 1 0  0.005fF
C162 1 0  0.005fF
C163 1 0  0.005fF
C164 1 0  0.005fF
C165 1 0  0.005fF
C166 1 0  0.005fF
C167 167 0  0.137fF
C168 168 0  0.137fF
C169 169 0  0.086fF
C170 170 0  0.137fF
C171 171 0  0.114fF
C172 172 0  0.086fF
C173 173 0  0.086fF
C174 174 0  0.114fF
C175 175 0  0.114fF
C176 1 0  0.005fF
C177 1 0  0.005fF
C178 1 0  0.005fF
C179 179 0  0.218fF
C180 1 0  0.005fF
C181 1 0  0.005fF
C182 1 0  0.005fF
C183 183 0  0.137fF
C184 184 0  0.218fF
C185 1 0  0.005fF
C186 1 0  0.005fF
C187 187 0  0.564fF
C188 188 0  0.218fF
C189 1 0  0.005fF
C190 1 0  0.005fF
C191 191 0  0.086fF
C192 192 0  0.114fF
C193 193 0  0.553fF
C194 1 0  0.005fF
C195 195 0  0.028fF
C196 196 0  0.028fF
C197 197 0  0.218fF
C198 1 0  0.005fF
C199 1 0  0.005fF
C200 200 0  0.028fF
C201 201 0  0.090fF
C202 1 0  0.005fF
C203 203 0  0.090fF
C204 204 0  0.090fF
C205 1 0  0.005fF
C206 1 0  0.005fF
C207 207 0  0.028fF
C208 1 0  0.005fF
C209 1 0  0.005fF
C210 1 0  0.005fF
C211 211 0  0.090fF
C212 1 0  0.005fF
C213 1 0  0.005fF
C214 214 0  0.190fF
C215 215 0  0.595fF
C216 1 0  0.005fF
C217 217 0  0.823fF
C218 1 0  0.005fF
C219 1 0  0.005fF
C220 220 0  0.776fF
C221 221 0  0.775fF
C222 1 0  0.059fF
C223 1 0  0.005fF
C224 224 0  0.114fF
C225 1 0  0.059fF
C226 226 0  0.869fF
C227 1 0  0.059fF
C228 228 0  0.114fF
C229 229 0  0.114fF
C230 1 0  0.059fF
C231 231 0  0.114fF
C232 232 0  0.115fF
C233 233 0  0.115fF
C234 234 0  0.115fF
C235 235 0  0.028fF
C236 236 0  0.115fF
C237 237 0  0.028fF
C238 238 0  0.091fF
C239 239 0  0.112fF
C240 240 0  0.028fF
C241 241 0  0.091fF
C242 242 0  0.112fF
C243 243 0  0.091fF
C244 244 0  0.112fF
C245 245 0  0.090fF
C246 246 0  0.028fF
C247 1 0  0.005fF
C248 248 0  0.090fF
C249 249 0  0.090fF
C250 1 0  0.005fF
C251 251 0  0.091fF
C252 252 0  0.112fF
C253 1 0  0.005fF
C254 1 0  0.005fF
C255 1 0  0.005fF
C256 1 0  0.005fF
C257 1 0  0.005fF
C258 1 0  0.005fF
C259 1 0  0.005fF
C260 260 0  0.090fF
C261 1 0  0.005fF
C262 1 0  0.005fF
C263 1 0  0.005fF
C264 1 0  0.005fF
C265 1 0  0.005fF
C266 1 0  0.005fF
C267 1 0  0.005fF
C268 1 0  0.005fF
C269 1 0  0.005fF
C270 1 0  0.005fF
C271 271 0  0.137fF
C272 272 0  0.137fF
C273 273 0  0.086fF
C274 274 0  0.137fF
C275 1 0  0.005fF
C276 276 0  0.114fF
C277 277 0  0.086fF
C278 278 0  0.086fF
C279 279 0  0.114fF
C280 280 0  0.114fF
C281 281 0  0.137fF
C282 1 0  0.005fF
C283 1 0  0.005fF
C284 284 0  0.086fF
C285 285 0  0.218fF
C286 1 0  0.005fF
C287 1 0  0.005fF
C288 1 0  0.005fF
C289 289 0  0.114fF
C290 290 0  0.218fF
C291 1 0  0.005fF
C292 1 0  0.005fF
C293 293 0  0.560fF
C294 294 0  0.218fF
C295 1 0  0.005fF
C296 1 0  0.005fF
C297 1 0  0.005fF
C298 298 0  0.551fF
C299 299 0  0.218fF
C300 1 0  0.005fF
C301 1 0  0.005fF
C302 302 0  0.028fF
C303 303 0  0.028fF
C304 304 0  0.028fF
C305 305 0  0.090fF
C306 306 0  0.028fF
C307 1 0  0.005fF
C308 308 0  0.090fF
C309 309 0  0.090fF
C310 1 0  0.005fF
C311 1 0  0.005fF
C312 312 0  0.090fF
C313 1 0  0.005fF
C314 1 0  0.005fF
C315 1 0  0.005fF
C316 1 0  0.005fF
C317 1 0  0.005fF
C318 318 0  0.180fF
C319 319 0  0.530fF
C320 1 0  0.005fF
C321 321 0  0.653fF
C322 1 0  0.005fF
C323 1 0  0.005fF
C324 1 0  0.005fF
C325 325 0  0.247fF
C326 326 0  0.646fF
C327 327 0  0.631fF
C328 1 0  0.059fF
C329 329 0  0.114fF
C330 1 0  0.059fF
C331 1 0  0.059fF
C332 1 0  0.059fF
C333 333 0  0.114fF
C334 334 0  0.114fF
C335 335 0  0.114fF
C336 336 0  0.115fF
C337 337 0  0.115fF
C338 338 0  0.115fF
C339 339 0  0.115fF
C340 340 0  0.028fF
C341 341 0  0.028fF
C342 342 0  0.028fF
C343 343 0  0.091fF
C344 344 0  0.112fF
C345 345 0  0.028fF
C346 346 0  0.091fF
C347 347 0  0.112fF
C348 348 0  0.091fF
C349 349 0  0.112fF
C350 350 0  0.091fF
C351 351 0  0.112fF
C352 352 0  0.090fF
C353 1 0  0.005fF
C354 354 0  0.090fF
C355 355 0  0.090fF
C356 356 0  0.090fF
C357 1 0  0.005fF
C358 1 0  0.005fF
C359 1 0  0.005fF
C360 1 0  0.005fF
C361 1 0  0.005fF
C362 1 0  0.005fF
C363 1 0  0.005fF
C364 1 0  0.005fF
C365 1 0  0.005fF
C366 1 0  0.005fF
C367 1 0  0.005fF
C368 1 0  0.005fF
C369 1 0  0.005fF
C370 1 0  0.005fF
C371 1 0  0.005fF
C372 1 0  0.005fF
C373 1 0  0.005fF
C374 1 0  0.005fF
C375 1 0  0.005fF
C376 376 0  0.137fF
C377 377 0  0.137fF
C378 378 0  0.137fF
C379 379 0  0.086fF
C380 380 0  0.137fF
C381 381 0  0.114fF
C382 382 0  0.086fF
C383 383 0  0.086fF
C384 384 0  0.086fF
C385 385 0  0.114fF
C386 386 0  0.114fF
C387 387 0  0.114fF
C388 1 0  0.005fF
C389 1 0  0.005fF
C390 1 0  0.005fF
C391 391 0  0.218fF
C392 1 0  0.005fF
C393 1 0  0.005fF
C394 1 0  0.005fF
C395 395 0  0.218fF
C396 1 0  0.005fF
C397 1 0  0.005fF
C398 398 0  0.218fF
C399 1 0  0.005fF
C400 1 0  0.005fF
C401 401 0  0.218fF
C402 1 0  0.005fF
C403 1 0  0.005fF
C404 404 0  0.028fF
C405 405 0  0.028fF
C406 406 0  0.028fF
C407 407 0  0.028fF
C408 408 0  0.090fF
C409 1 0  0.005fF
C410 410 0  0.090fF
C411 411 0  0.090fF
C412 412 0  0.090fF
C413 1 0  0.005fF
C414 1 0  0.005fF
C415 1 0  0.005fF
C416 1 0  0.005fF
C417 1 0  0.005fF
C418 1 0  0.005fF
C419 1 0  0.005fF
C420 420 0  0.006fF
C421 421 0  0.006fF
C423 423 0  0.006fF
C424 424 0  0.006fF
C428 428 0  0.006fF
C429 429 0  0.006fF
C431 431 0  0.006fF
C432 432 0  0.006fF
C440 440 0  0.005fF
C441 441 0  0.005fF
C443 443 0  0.005fF
C444 444 0  0.005fF
C451 451 0  0.005fF
C452 452 0  0.005fF
C454 454 0  0.005fF
C455 455 0  0.005fF
C468 468 0  0.005fF
C469 469 0  0.005fF
C470 470 0  0.005fF
C472 472 0  0.005fF
C477 477 0  0.005fF
C479 479 0  0.005fF
C480 480 0  0.005fF
C481 481 0  0.005fF
C492 492 0  0.006fF
C493 493 0  0.006fF
C495 495 0  0.006fF
C496 496 0  0.006fF
C498 498 0  0.006fF
C499 499 0  0.006fF
C504 504 0  0.006fF
C505 505 0  0.006fF
C513 513 0  0.005fF
C514 514 0  0.005fF
C516 516 0  0.005fF
C517 517 0  0.005fF
C518 518 0  0.005fF
C519 519 0  0.005fF
C528 528 0  0.005fF
C529 529 0  0.005fF
C542 542 0  0.005fF
C543 543 0  0.005fF
C544 544 0  0.005fF
C545 545 0  0.005fF
C546 546 0  0.005fF
C547 547 0  0.005fF
C553 553 0  0.005fF
C554 554 0  0.005fF
C564 564 0  0.006fF
C565 565 0  0.006fF
C567 567 0  0.006fF
C568 568 0  0.006fF
C570 570 0  0.006fF
C571 571 0  0.006fF
C575 575 0  0.006fF
C576 576 0  0.006fF
C586 586 0  0.005fF
C587 587 0  0.005fF
C589 589 0  0.005fF
C590 590 0  0.005fF
C591 591 0  0.005fF
C592 592 0  0.005fF
C597 597 0  0.005fF
C598 598 0  0.005fF
C614 614 0  0.005fF
C615 615 0  0.005fF
C617 617 0  0.005fF
C618 618 0  0.005fF
C620 620 0  0.005fF
C621 621 0  0.005fF
C622 622 0  0.005fF
C625 625 0  0.005fF
C636 636 0  0.006fF
C637 637 0  0.006fF
C639 639 0  0.006fF
C640 640 0  0.006fF
C642 642 0  0.006fF
C643 643 0  0.006fF
C645 645 0  0.006fF
C646 646 0  0.006fF
C659 659 0  0.005fF
C660 660 0  0.005fF
C662 662 0  0.005fF
C663 663 0  0.005fF
C664 664 0  0.005fF
C665 665 0  0.005fF
C666 666 0  0.005fF
C667 667 0  0.005fF
C688 688 0  0.005fF
C689 689 0  0.005fF
C690 690 0  0.005fF
C691 691 0  0.005fF
C692 692 0  0.005fF
C693 693 0  0.005fF
C694 694 0  0.005fF
C695 695 0  0.005fF
C709 709 0  0.800fF
C710 710 0  0.928fF
C711 711 0  0.757fF
C712 712 0  0.782fF
C714 714 0  0.773fF
C717 717 0  0.802fF
C718 718 0  0.806fF
C720 720 0  0.220fF
C721 721 0  0.037fF
C722 722 0  0.037fF
C723 723 0  0.037fF
C724 724 0  0.037fF
C725 725 0  0.802fF
C726 726 0  0.220fF
C728 728 0  0.037fF
C729 729 0  0.037fF
C730 730 0  0.010fF
C731 731 0  0.010fF
*
*
* n-MOS BSIM4 :
* Low leakage, SVT
.MODEL N1 NMOS LEVEL=14 VTHO=0.300 U0=0.021 TOXE= 1.1E-9 LINT=0.000U
+K1 =0.700 K2=0.000 DVT0=1.300
+DVT1=0.500 LPE0=1.200e-9 ETA0=0.080
+NFACTOR=  1.1 UA=6.500e-15
+WINT=0.000U UC=-0.047e-15 PSCBE1=500.000e6
+KT1=-0.060 UTE=-1.800
+XJ=0.150U NDEP=170.000e15 PCLM=1.100
+VSAT=100000.000 VOFF=0.000
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* p-MOS BSIM4:
* Low leakage, SVT
.MODEL P1 PMOS LEVEL=14 VTHO=-0.300 U0=0.024 TOXE= 1.1E-9 LINT=0.000U
+K1 =0.640 K2=0.000 DVT0=2.200
+DVT1=0.590 LPE0=1.200e-9 ETA0=0.080
+NFACTOR=  1.1 UA=6.500e-15
+WINT=0.000U UC=-0.047e-15 PSCBE1=500.000e6
+KT1=-0.060 UTE=-1.800
+XJ=0.150U NDEP=170.000e15 PCLM=0.700
+VSAT=60000.000 VOFF=0.000
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* Transient analysis
*
* (Winspice)
.options temp=27.0
.control
tran 0.1N 5.000N
print  V(398) V(299) V(197) V(76) V(391) V(285) V(179) V(72) V(401) V(294) V(188) V(90) V(395) V(290) V(184) V(86) V(709) V(718) V(714) V(325) V(710) V(711) V(717) V(712) V(3) V(2) V(8) V(5) V(110) V(214) V(318) V(725) > out.txt
plot  V(398) V(299) V(197) V(76) V(391) V(285) V(179) V(72) V(401) V(294) V(188) V(90) V(395) V(290) V(184) V(86) V(709) V(718) V(714) V(325) V(710) V(711) V(717) V(712) V(3) V(2) V(8) V(5) V(110) V(214) V(318) V(725)
.endc
.END
